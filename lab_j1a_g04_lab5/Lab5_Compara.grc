options:
  parameters:
    author: 'Adiana Jairo '
    copyright: UIS
    generate_options: qt_gui
    id: Compara
    output_language: python
    title: Compara
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: of
  id: variable_qtgui_range
  parameters:
    label: offset
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: ModulosEfren_Compara_0
  id: ModulosEfren_Compara
  parameters: {}
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '10000'
    offset: of
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModulosEfren_Compara_0, '0', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0, '0', ModulosEfren_Compara_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_1, '0', ModulosEfren_Compara_0, '1']
- [analog_sig_source_x_1, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
