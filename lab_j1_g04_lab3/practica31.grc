options:
  parameters:
    author: uis-e3t
    generate_options: qt_gui
    id: trasmisorAM
    output_language: python
    title: jairo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: variable_qtgui_range_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: variable_qtgui_range_3
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: variable_qtgui_range_4
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '200000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: calculopotenciacomunicaciones_0
  id: calculopotenciacomunicaciones
  parameters:
    I_vect: '1024000'
  states: {}
- name: moduladorAM_j1A_G6_0
  id: moduladorAM_j1A_G6
  parameters:
    ac: 100m
    ka: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '50000000'
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: '200000'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', calculopotenciacomunicaciones_0, '0']
- [analog_sig_source_x_0, '0', moduladorAM_j1A_G6_0, '0']
- [moduladorAM_j1A_G6_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
