options:
  parameters:
    author: jairo andres sanchez
    copyright: '2021'
    description: sample rate demo
    generate_options: qt_gui
    id: options
    output_language: python
    title: sample rate demo
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '1000'
    step: '1000'
    stop: '40000'
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '32000'
    fc: '0'
    fftsize: '2048'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '128'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
