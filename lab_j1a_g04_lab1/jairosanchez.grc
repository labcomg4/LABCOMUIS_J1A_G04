options:
  parameters:
    author: andresuis
    generate_options: qt_gui
    id: jairosanchez
    output_language: python
    title: proyecto2
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1e-4'
    stop: '1'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    orient: Qt.Horizontal
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
